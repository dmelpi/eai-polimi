# Keil uVision project Project.uvprojx, settings and files
target FP_AI_MONITOR1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4R9ZIJx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) XRAM(0x20040000,0x00060000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: FP_AI_MONITOR1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: SYS_TP_MCU_STM32L4,STM32L4R9xx,STM32L4R9ZIJx,STEVAL_STWINKT1,DEBUG,SYS_DEBUG,USE_HAL_DRIVER,USE_FULL_ASSERT,SYS_TRACE=0,SYS_DBG_ENABLE_TA4=0,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --preinclude=../../Inc/sysconfig.h
  c include: ../Inc;../X-CUBE-AI/App;../SensorManager/Inc;../signal_processing_lib/lib_features_extraction/Inc;../signal_processing_lib/gravity_filter/Inc;../DPU/Inc;../mx/Inc;../../../../../Drivers/CMSIS/Core/Include;../../../../../Drivers/CMSIS/DSP/Include;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/iis3dwb;../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/lps22hh;../../../../../Middlewares/ST/eLooM/Inc;../../../../../Middlewares/ST/eLooM/Inc/ta4_recorder/include;../../../../../Middlewares/ST/eLooM/Inc/ta4_recorder/config;../../../../../Middlewares/ST/NanoEdge_AI_Library/Inc;../../../../../Middlewares/ST/STM32_AI_Library/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../../../Middlewares/ST/STM32_GenericFFT_Library/Inc;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/User
    ../Src/: AITask.c App.c app_messages_parser.c AppController.c AppPowerModeHelper.c cli_commands.c exti_pin_map.c free_rtos_hooks.c FreeRTOS_CLI.c HelloWorldTask.c main.c NeaiTask.c stm32_assert.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c usbd_cdc_if.c usbd_conf.c usbd_desc.c UtilTask.c
    ../Src/services/: BCProtocol.c ai_helper.c
    ../Src/drivers/: BCDriver.c
  group Application/DPU
    ../DPU/Src/: ADPU.c AiDPU.c CircularBuffer.c NeaiDPU.c IDPU.c
    ../DPU/Src/events/: IProcessEventListener.c ProcessEvent.c ProcessEventSrc.c
  group Application/SensorManager
    ../SensorManager/Src/: ABusIF.c EnvTask.c HTS221Class.c HTS221Task.c I2CBusIF.c I2CBusTask.c IBus.c IIS3DWBTask.c IMP23ABSUTask.c ISensor.c ISM330DHCXTask.c LPS22HHClass.c LPS22HHTask.c SensorManager.c SMMessageParser.c SMUtilTask.c SPIBusIF.c SPIBusTask.c
    ../SensorManager/Src/services/: SIterator.c SQuery.c
    ../SensorManager/Src/events/: ISensorEventListener.c SensorEvent.c SensorEventSrc.c
    ../SensorManager/Src/drivers/: AnalogMicDriver.c DFSDMDriver.c I2CMasterDriver.c SMUtilityDriver.c SPIMasterDriver.c
  group Application/X-Cube-AI
    ../X-CUBE-AI/App/: aiApp.c aiTestHelper.c app_x-cube-ai.c network.c network_data.c
  group Application/gravity_fliter
    ../signal_processing_lib/gravity_filter/Src/: filter_gravity.c
  group Application/lib_features_extraction
    ../signal_processing_lib/lib_features_extraction/Src/: ai_logging.c features_extraction.c
  group Application/MX
    ../mx/Src/: adc.c dfsdm.c dma.c i2c.c mx.c spi.c sysinit_mx.c tim.c usart.c gpio.c
  group Application/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/eLooM
    ../../../../../Middlewares/ST/eLooM/Src/drivers/: IDriver.c IIODriver.c
    ../../../../../Middlewares/ST/eLooM/Src/events/: AEventSrc.c IEvent.c IEventListener.c IEventSrc.c IListener.c ISourceObservable.c
    ../../../../../Middlewares/ST/eLooM/Src/services/: AManagedTask.c AManagedTaskEx.c ApplicationContext.c IApplicationErrorDelegate.c IAppPowerModeHelper.c IBoot.c IErrorFirstResponder.c NullErrorDelegate.c sysdebug.c SysDefPowerModeHelper.c syserror.c sysinit.c
    ../../../../../Middlewares/ST/eLooM/Src/ta4_recorder/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
  group Middlewares/NanoEdge_AI_Library
    ../../../../../Middlewares/ST/NanoEdge_AI_Library/Lib/: libneai.lib
  group Middlewares/STM32_AI_Library
    ../../../../../Middlewares/ST/STM32_AI_Library/Lib/: NetworkRuntime700_CM4_Keil.lib
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c
    ../../../../../Drivers/BSP/Components/iis3dwb/: iis3dwb_reg.c
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_exti.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pka.c stm32l4xx_hal_pssi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pka.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
  group Middlewares/STM32_USB_Device_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
