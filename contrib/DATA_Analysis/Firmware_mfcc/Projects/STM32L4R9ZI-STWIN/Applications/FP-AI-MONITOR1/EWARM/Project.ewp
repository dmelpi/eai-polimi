# IAR project Project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32L4R9ZI ST STM32L4R9ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SYS_TP_MCU_STM32L4; STM32L4R9xx; STM32L4R9ZIJx; STEVAL_STWINKT1; USE_HAL_DRIVER; SYS_TRACE=0; SYS_DBG_ENABLE_TA4=0; ARM_MATH_CM4; __FPU_PRESENT
  ICCARM.PreInclude: ..\Inc\sysconfig.h
  ICCARM.CCIncludePath2: ..\Inc; ..\X-CUBE-AI\App; ..\SensorManager\Inc; ..\signal_processing_lib\lib_features_extraction\Inc; ..\signal_processing_lib\gravity_filter\Inc; ..\DPU\Inc; ..\mx\Inc; ..\..\..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\iis3dwb; ..\..\..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\Middlewares\ST\eLooM\Inc; ..\..\..\..\..\Middlewares\ST\STM32_AI_Library\Inc; ..\..\..\..\..\Middlewares\ST\NanoEdge_AI_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\..\Middlewares\ST\STM32_GenericFFT_Library\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\Drivers\CMSIS\DSP\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: FP_AI_MONITOR1.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l4r9xI_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Middlewares\ST\STM32_AI_Library\Lib\NetworkRuntime700_CM4_IAR.a; ..\..\..\..\..\Middlewares\ST\NanoEdge_AI_Library\Lib\libneai.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SYS_TP_MCU_STM32L4; STM32L4R9xx; STM32L4R9ZIJx; STEVAL_STWINKT1; DEBUG; SYS_DEBUG; USE_HAL_DRIVER; USE_FULL_ASSERT; SYS_TRACE=0; SYS_DBG_ENABLE_TA4=0; ARM_MATH_CM4; __FPU_PRESENT
  ICCARM.CCOptLevel: 0
configuration Trace (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SYS_TP_MCU_STM32L4; STM32L4R9xx; STM32L4R9ZIJx; STEVAL_STWINKT1; USE_HAL_DRIVER; SYS_TRACE=0; SYS_DBG_ENABLE_TA4=1; ARM_MATH_CM4; __FPU_PRESENT
  ICCARM.CCIncludePath2: ..\Inc; ..\X-CUBE-AI\App; ..\SensorManager\Inc; ..\signal_processing_lib\lib_features_extraction\Inc; ..\signal_processing_lib\gravity_filter\Inc; ..\DPU\Inc; ..\mx\Inc; ..\..\..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\iis3dwb; ..\..\..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\Middlewares\ST\eLooM\Inc; ..\..\..\..\..\Middlewares\ST\eLooM\Inc\ta4_recorder\include; ..\..\..\..\..\Middlewares\ST\eLooM\Inc\ta4_recorder\config; ..\..\..\..\..\Middlewares\ST\STM32_AI_Library\Inc; ..\..\..\..\..\Middlewares\ST\NanoEdge_AI_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\..\Middlewares\ST\STM32_GenericFFT_Library\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\Drivers\CMSIS\DSP\Include
  group Application/dpu
    ../DPU/Src/: ADPU.c AiDPU.c CircularBuffer.c IDPU.c NeaiDPU.c
  group Application/dpu/events
    ../DPU/Src/events/: IProcessEventListener.c ProcessEvent.c ProcessEventSrc.c
  group Application/gravity_filter
    ../signal_processing_lib/gravity_filter/Src/: filter_gravity.c
  group Application/lib_features_extraction
    ../signal_processing_lib/lib_features_extraction/Src/: ai_logging.c features_extraction.c
  group Application/Mx
    ../mx/Src/: adc.c dfsdm.c dma.c gpio.c i2c.c mx.c spi.c sysinit_mx.c tim.c usart.c
  group Application/SensorManager
    ../SensorManager/Src/: ABusIF.c EnvTask.c HTS221Class.c I2CBusIF.c I2CBusTask.c IBus.c IIS3DWBTask.c IMP23ABSUTask.c ISensor.c ISM330DHCXTask.c LPS22HHClass.c SensorManager.c SMMessageParser.c SMUtilTask.c SPIBusIF.c SPIBusTask.c
  group Application/SensorManager/Drivers
    ../SensorManager/Src/drivers/: AnalogMicDriver.c DFSDMDriver.c I2CMasterDriver.c SMUtilityDriver.c SPIMasterDriver.c
  group Application/SensorManager/Events
    ../SensorManager/Src/events/: ISensorEventListener.c SensorEvent.c SensorEventSrc.c
  group Application/SensorManager/Services
    ../SensorManager/Src/services/: SIterator.c SQuery.c
  group Application/Startup
    ./: startup_stm32l4r9xx.s syscalls.c
  group Application/User
    ../Src/: AITask.c App.c app_messages_parser.c AppController.c AppPowerModeHelper.c cli_commands.c exti_pin_map.c free_rtos_hooks.c FreeRTOS_CLI.c HelloWorldTask.c main.c NeaiTask.c stm32_assert.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c usbd_cdc_if.c usbd_conf.c usbd_desc.c UtilTask.c
  group Application/User/drivers
    ../Src/drivers/: BCDriver.c
  group Application/User/services
    ../Src/services/: ai_helper.c BCProtocol.c
  group Application/X-CUBE-AI
    ../X-CUBE-AI/App/: aiApp.c aiTestHelper.c app_x-cube-ai.c network.c network_data.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c
    ../../../../../Drivers/BSP/Components/iis3dwb/: iis3dwb_reg.c
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_exti.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pka.c stm32l4xx_hal_pssi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_smbus_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pka.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
  group Middlewares/eLooM/Drivers
    ../../../../../Middlewares/ST/eLooM/Src/drivers/: IDriver.c IIODriver.c
  group Middlewares/eLooM/Events
    ../../../../../Middlewares/ST/eLooM/Src/events/: AEventSrc.c IEvent.c IEventListener.c IEventSrc.c IListener.c ISourceObservable.c
  group Middlewares/eLooM/Services
    ../../../../../Middlewares/ST/eLooM/Src/services/: AManagedTask.c AManagedTaskEx.c ApplicationContext.c IApplicationErrorDelegate.c IAppPowerModeHelper.c IBoot.c IErrorFirstResponder.c NullErrorDelegate.c sysdebug.c SysDefPowerModeHelper.c syserror.c sysinit.c
  group Middlewares/eLooM/Ta4_Recorder
    ../../../../../Middlewares/ST/eLooM/Src/ta4_recorder/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/STM32_GenericFFT_Library
    ../../../../../Middlewares/ST/STM32_GenericFFT_Library/Src/: fft.c
  group Middlewares/STM32_USB_Device_Library/Class/CDC
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USB_Device_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
